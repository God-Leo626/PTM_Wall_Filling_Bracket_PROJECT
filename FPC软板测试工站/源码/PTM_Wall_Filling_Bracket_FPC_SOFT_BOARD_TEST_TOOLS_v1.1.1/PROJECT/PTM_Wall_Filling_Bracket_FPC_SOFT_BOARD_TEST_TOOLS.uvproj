# Keil uVision project PTM_Wall_Filling_Bracket_FPC_SOFT_BOARD_TEST_TOOLS.uvproj, settings and files
target F4_MINI_ZB_RBS_lei_diao_tool (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: PTM_Wall_Filling_Bracket_FPC_SOFT_BOARD_TEST_TOOLS +hex
  c flags: wLevel=1
  c define: STM32F40XX USE_STDPERIPH_DRIVER  USE_USB_OTG_FS
  c misc: --c99
  c include: ..\USER;..\LIB\inc;..\APP\LCD;..\APP\lvgl;..\APP\TIME;..\APP\usart;..\CMSIS;..\APP\USB\USB_APP;..\APP\USB\STM32_USB_OTG_Driver\inc;..\APP\USB\STM32_USB_Device_Library\Class\cdc\inc;..\APP\USB\STM32_USB_Device_Library\Core\inc;..\APP\USB\STM32_USB_Device_Library\Core\src;..\APP\FIFO;..\APP\TIM;..\APP\GPIO;..\APP\KEY;..\USER;..\APP\CMD;..\APP\IIC;..\APP\SHT4x;..\APP\NDS03;..\APP\NDS03\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/LCD/: font.c lcd.c display.c
    ../APP/TIME/: time.c
    ../APP/usart/: usart.c
    ../APP/FIFO/: fifo.c
    ../APP/TIM/: timer.c
    ../APP/KEY/: key.c
    ../APP/GPIO/: gpio.c
    ../APP/CMD/: cmd.c
    ../APP/IIC/: bsp_iic.c
    ../APP/SHT4x/: sht4xx.c
  group cmsis
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40xx.s
  group LIB
    ../LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../USER/: main.c user.c
  group USB_OTG
    ../APP/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../APP/USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../APP/USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_APP
    ../APP/USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_cdc_vcp.c usbd_usr.c
  group NDS03
    ../APP/NDS03/: nds03_app.c nds03_platform.c
    ../APP/NDS03/src/: nds03_comm.c nds03_dev.c nds03_data.c nds03_calib.c
